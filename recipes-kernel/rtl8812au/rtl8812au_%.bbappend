EXTRA_CFLAGS = "-DCONFIG_LITTLE_ENDIAN -DCONFIG_IOCTL_CFG80211 -DRTW_USE_CFG80211_STA_EVENT"
EXTRA_OEMAKE += "CFLAGS='${EXTRA_CFLAGS}'"
